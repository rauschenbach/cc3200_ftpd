<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
          </package>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
          </package>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
          </package>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
          </package>
        </cstatsettings>
      </data>
    </settings>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>0</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>ftp</name>
    <file>
      <name>$PROJ_DIR$\..\ftp\cmds.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\ftp\ftpd.c</name>
    </file>
  </group>
  <group>
    <name>periph</name>
    <file>
      <name>$PROJ_DIR$\..\periph\board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\periph\lantask.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\periph\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\periph\rtos_handlers.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cc3200_libs\common\startup_ewarm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\periph\twi.c</name>
    </file>
  </group>
  <group>
    <name>sdcard</name>
    <file>
      <name>$PROJ_DIR$\..\sdcard\sdcard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\sdcard\sdreader.c</name>
    </file>
  </group>
  <group>
    <name>utils</name>
    <file>
      <name>$PROJ_DIR$\..\utils\userfunc.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\main.c</name>
  </file>
</project>



# IAR project ftpd_test.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; ENABLE_NEW_SIVY; TARGET_IS_CC3200; NDEBUG
  ICCARM.CCIncludePath2: ; ..\; ..\ftp; ..\periph; ..\sdcard; ..\utils; ..\..\cc3200_libs\common; ..\..\cc3200_libs\inc\; ..\..\cc3200_libs\simplelink\; ..\..\cc3200_libs\simplelink\include\; ..\..\cc3200_libs\simplelink_extlib\provisioninglib\; ..\..\cc3200_libs\driverlib\; ..\..\cc3200_libs\fatfs\; ..\..\cc3200_libs\oslib; C:\Program Files\IAR Systems\Embedded Workbench 7.2\arm\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: ndas.bin
  ILINK.IlinkOutputFile: ftpd_test.out
  ILINK.IlinkConfigDefines: TARGET_IS_CC3200=1
  ILINK.IlinkIcfFile: cc3200.icf
  ILINK.IlinkAdditionalLibs: ..\..\cc3200_libs\ewarm_libs\fatfs.a; ..\..\cc3200_libs\ewarm_libs\free_rtos.a; ..\..\cc3200_libs\ewarm_libs\simplelink.a; ..\..\cc3200_libs\ewarm_libs\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c
  group ftp
    ../ftp/: cmds.c ftpd.c
  group periph
    ../periph/: board.c lantask.c led.c rtos_handlers.c twi.c
    ../../cc3200_libs/common/: startup_ewarm.c
  group sdcard
    ../sdcard/: sdcard.c sdreader.c
  group utils
    ../utils/: userfunc.c
